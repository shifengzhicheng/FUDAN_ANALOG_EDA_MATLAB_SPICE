Vin 1 0 ac 1 1 0

R1 1 2 10
C1 2 0 4e-6

R2 2 3 20
C2 3 0 7e-8

R3 3 4 1000
C3 4 0 5e-12

L1 4 0 5e-5
C4 4 0 8e-10

.pz

.plotnv 2
