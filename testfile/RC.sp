Vin 11 0 ac 0 1 90

Rin 11 21 1

Co 21 0 1e-10

.plotnv 21

.ac DEC 10 1K 100MEG
